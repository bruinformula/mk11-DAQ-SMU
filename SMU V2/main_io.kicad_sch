File: SMU V2/main_io.kicad_sch (KiCad schematic)
At the start: 6 parts, among them J401 Connector, J402 Connector

Commit message: v2 layout
Other:
- moved on the sheet: C403, C404, J402
